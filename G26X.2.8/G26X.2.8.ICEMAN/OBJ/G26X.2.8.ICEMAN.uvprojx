# Keil uVision project G26X.2.8.ICEMAN.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME53J18A Microchip
  pack: Atmel.SAME53_DFP.1.1.118
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: G26X.2.8.ICEMAN.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
